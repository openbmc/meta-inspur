FILESEXTRAPATHS_prepend_dubai := "${THISDIR}/${PN}:"
SRC_URI_append_dubai = " file://dubai.cfg"
