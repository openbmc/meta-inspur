RDEPENDS_${PN}_remove_dubai = "p9-vcs-workaround"
