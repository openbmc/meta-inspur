FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

OBMC_ORG_YAML_SUBDIRS += " org/open_power com/ibm"
