FILESEXTRAPATHS_prepend_fp5280g2 := "${THISDIR}/${PN}:"
SRC_URI_append_fp5280g2 = " file://fp5280g2.cfg"
