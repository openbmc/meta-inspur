EXTRA_OEMESON_append_fp5280g2 = " -Dverify-signature=enabled"
