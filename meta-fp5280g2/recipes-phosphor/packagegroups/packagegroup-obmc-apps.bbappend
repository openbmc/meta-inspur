RDEPENDS_${PN}-inventory_append_fp5280g2 = "openpower-occ-control"
