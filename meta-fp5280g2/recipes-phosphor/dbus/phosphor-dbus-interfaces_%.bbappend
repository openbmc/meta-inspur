FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

OBMC_ORG_YAML_SUBDIRS_append_fp5280g2 = " org/open_power com/ibm"
