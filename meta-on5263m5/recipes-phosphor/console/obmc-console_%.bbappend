FILESEXTRAPATHS_prepend_on5263m5:= "${THISDIR}/${PN}:"
